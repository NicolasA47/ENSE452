# Keil uVision project ense452L2.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ense351A3
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c util.c util.h CLI.c CLI.h Elevator.c Elevator.h main.h
software components: RTOS:Config 10.3.1, RTOS:Core 10.3.1, RTOS:Coroutines 10.3.1, RTOS:Event Groups 10.3.1, RTOS:Heap 10.3.1, RTOS:Message Buffer 10.3.1, RTOS:Stream Buffer 10.3.1, RTOS:Timers 10.3.1, CMSIS:CORE 5.5.0, CMSIS:RTOS2:FreeRTOS 10.3.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
